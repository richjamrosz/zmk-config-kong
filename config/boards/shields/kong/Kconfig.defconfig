## config/boards/shields/kong/Kconfig.defconfig
```kconfig
if SHIELD_KONG

config ZMK_KEYBOARD_NAME
    default "kong"

config ZMK_USB
    default y

endif
```
